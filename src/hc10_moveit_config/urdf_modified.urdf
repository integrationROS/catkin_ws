Commit message: combination of RViz and Gazebo

File: src/hc10_moveit_config/urdf_modified.urdf (robot description, URDF)
Before this commit: robot motoman_hc10, 10 links, 9 joints
Joints:
- joint world_fixed: origin (none) -> xyz=0 0 0.5 rpy=0 0 0
